v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 30 -70 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 30 -40 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 30 -10 0 0 {name=p3 lab=LOn}
C {devices/iopin.sym} 30 20 0 0 {name=p4 lab=LOp}
C {devices/iopin.sym} 30 50 0 0 {name=p5 lab=RFn}
C {devices/iopin.sym} 30 80 0 0 {name=p6 lab=RFp}
C {devices/iopin.sym} 30 110 0 0 {name=p7 lab=IFp}
C {devices/iopin.sym} 30 140 0 0 {name=p8 lab=IFn}
