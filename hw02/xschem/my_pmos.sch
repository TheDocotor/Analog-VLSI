v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 -60 0 0 {name=p1 lab=D}
C {devices/iopin.sym} 0 -30 0 0 {name=p2 lab=G}
C {devices/iopin.sym} 0 0 0 0 {name=p3 lab=S}
C {devices/iopin.sym} 0 30 0 0 {name=p4 lab=B}
